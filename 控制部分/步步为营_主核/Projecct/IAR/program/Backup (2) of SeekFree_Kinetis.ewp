# IAR project Backup (2) of SeekFree_Kinetis.ewp, settings and files
configuration MK60DN_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MK60DN; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\FatFs; ..\..\..\Libraries\FatFs\option
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SeekFree_Kinetis.srec
  ILINK.IlinkOutputFile: SeekFree_Kinetis.out
  ILINK.IlinkIcfFile: linker\MK60xN512_10.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MK60FX_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 NXP MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.FPU2: 4
  ICCARM.CCDefines: MK60FX; MK60F15; _DLIB_FILE_DESCRIPTOR; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\FatFs; ..\..\..\Libraries\FatFs\option; ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\seekfree
  ILINK.IlinkIcfFile: linker\MK60xX512_15.icf
  group creative/inc
    ../../USER/inc/: All_solution.h Communication.h CtrDelay.h ctrl_basic.h ctrl_pid.h CtrSpeed.h duty.h edge_extract.h Encoder.h Find_path.h image_binaryzation.h Init.h isr.h lcd.h menu.h Moto.h Pos_cal.h Switch.h VCAN_key.h VCAN_Servo.h VCAN_Track.h
    ../../../Libraries/drives/inc/: headfile.h
  group creative/src
    ../../USER/src/: All_solution.c Communication.c CtrDelay.c ctrl_basic.c ctrl_pid.c CtrSpeed.c duty.c edge_extract.c Encoder.c Find_path.c image_binaryzation.c Init.c isr.c lcd.c menu.c Moto.c Pos_cal.c Switch.c VCAN_key.c VCAN_Servo.c VCAN_Track.c
  group creative/user_c
    ../../USER/src/: IRQHandler.c main.c
    ../../../Libraries/: version.txt
  group drives/inc
    ../../../Libraries/drives/inc/: common.h misc.h MK60_adc.h MK60_cmt.h MK60_dac.h MK60_dma.h MK60_flash.h MK60_ftm.h MK60_gpio.h MK60_i2c.h MK60_lptmr.h MK60_pit.h MK60_port.h MK60_port_cfg.h MK60_rtc.h MK60_sdhc.h MK60_spi.h MK60_systick.h MK60_uart.h MK60_wdog.h
  group drives/src
    ../../../Libraries/drives/src/: common.c misc.c MK60_adc.c MK60_cmt.c MK60_dac.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_pit.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_systick.c MK60_uart.c MK60_wdog.c
  group fatfs
    ../../../Libraries/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group seekfree
    ../../../Libraries/seekfree/: Attitude_Calculation.c Attitude_Calculation.h BMX055.c BMX055.h DataStore.c DataStore.h FXAS2100_FXOS8700.c FXAS2100_FXOS8700.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SoftIIC.c SoftIIC.h WHUT_freecars.c WHUT_freecars.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s startup_MK60F15.s
    ../../../Libraries/startup/DeviceSupport/: system_MK60.c
  group user_h
    ../../USER/inc/: IRQHandler.h
